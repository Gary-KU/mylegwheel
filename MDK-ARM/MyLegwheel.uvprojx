# Keil uVision project MyLegwheel.uvprojx, settings and files
target MyLegwheel (6160000::V6.16::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: MyLegwheel +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__FPU_PRESENT=1U,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,MYLEGWHEEL_A1_CURRENT=1
  c include: ../Core/Inc;../App/Tasks/Inc;../App/Services/Inc;../App/Protocol/Inc;../BSP/Peripherals/Inc;../BSP/BMI088/Inc;../BSP/DWT/Inc;../Algorithms/Attitude/Inc;../Algorithms/PID/Inc;../Control/WheelLeg/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: MyLegwheel.sct
  group Startup
    ./: startup_stm32h723xx.s
  group Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c system_stm32h7xx.c
  group App/Tasks
    ../App/Tasks/Src/: wheel_leg_task.c wheel_leg_runtime.c wheel_leg_observer.c can_task.c imu_task.c
    ../App/Tasks/Inc/: wheel_leg_task.h wheel_leg_runtime.h wheel_leg_observer.h wheel_leg_config.h can_task.h imu_task.h
  group App/Services
    ../App/Services/Src/: motor_command.c motor_foc.c joint_calibration.c board_feedback.c sbus_receiver.c lqr_startup_record.c robot_telemetry_service.c lqr_record_flash.c
    ../BSP/Peripherals/Src/: bsp_fdcan_deadline.c
    ../App/Services/Inc/: motor_foc.h motor_foc_config.h motor_command.h joint_calibration.h joint_calibration_config.h board_feedback.h sbus_receiver.h robot_telemetry_service.h robot_telemetry_config.h
  group App/Protocol
    ../App/Protocol/Src/: ano_v7.c robot_telemetry.c sbus_decoder.c sbus_sticks.c robot_motion_command.c
    ../App/Protocol/Inc/: ano_v7.h robot_telemetry.h sbus_decoder.h sbus_sticks.h robot_motion_command.h
  group BSP/Peripherals
    ../BSP/Peripherals/Src/: bsp_telemetry_uart.c bsp_spi.c bsp_tim.c bsp_fdcan.c bsp_sbus.c
    ../BSP/Peripherals/Inc/: bsp_telemetry_uart.h bsp_fdcan.h bsp_spi.h bsp_tim.h bsp_sbus.h
  group BSP/BMI088
    ../BSP/BMI088/Src/: bmi088_driver.c bmi088_port.c
    ../BSP/BMI088/Inc/: bmi088_driver.h bmi088_port.h bmi088_reg.h
  group BSP/DWT
    ../BSP/DWT/Src/: bsp_dwt.c
    ../BSP/DWT/Inc/: bsp_dwt.h
  group Algorithms/Attitude
    ../Algorithms/Attitude/Src/: mahony_ahrs.c
    ../Algorithms/Attitude/Inc/: mahony_ahrs.h
  group Algorithms/PID
    ../Algorithms/PID/Src/: pid.c
    ../Algorithms/PID/Inc/: pid.h
  group Control/WheelLeg
    ../Control/WheelLeg/Src/: leg_pos.c lqr_k.c
    ../Control/WheelLeg/Inc/: leg_model.h leg_pos.h lqr_k.h
  group USB_DEVICE
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
